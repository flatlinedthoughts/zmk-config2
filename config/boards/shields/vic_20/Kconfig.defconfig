## config/boards/shields/vic_20/Kconfig.defconfig
```kconfig
if SHIELD_VIC_20

config ZMK_KEYBOARD_NAME
    default "Spaghetti" //to match my pile of spaghetti that is my handwired board

endif
```
